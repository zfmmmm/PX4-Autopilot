## src/examples/depth_sensor/Kconfig
```kconfig
menuconfig EXAMPLES_DEPTH_SENSOR
        bool "Depth Sensor Serial"
        default n
        ---help---
                Depth Sensor Serial
```
